#INCLUDE <P16F84A.INC>
CBLOCK 0x20
CONTADOR
ENDC
SETUP
    BSF STATUS, RP0
    MOVLW 0x02
    MOVWF TRISB
    MOVLW 0x00
    MOVWF TRISA
    BCF OPTION_REG, NOT_RBPU
    BCF STATUS, RP0

MAIN
    MOVLW 0x00
    MOVWF PORTA
    GOTO LOOP

LOOP
    BTFSC PORTB, RB1
    GOTO LOOP
    GOTO INCREMENTAR

INCREMENTAR
    INCF CONTADOR
    MOVFW CONTADOR
    MOVWF PORTA
    ESPERAR
        BTFSC PORTB, RB1
        GOTO LOOP
        GOTO ESPERAR

END